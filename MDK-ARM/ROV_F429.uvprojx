# Keil uVision project ROV_F429.uvprojx, settings and files
target ROV_F429 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: ROV_F429 +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Inc;   ../Drivers/STM32F4xx_HAL_Driver/Inc;   ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;   ../Drivers/CMSIS/Include;   ..\MDK-ARM;   ../Middlewares/Third_Party/FreeRTOS/Source/include;   ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;   ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;   ..\USER;   ..\USER\CONTROL;   ..\USER\DRIVER;   ..\USER\MATH;   ..\USER\MESSAGE;   ..\USER\TASK;   ..\USER\W5500;   ..\USER\STMFLASH;   ..\USER\Version;   ..\USER\CANNetwork
  asm include: ..\\Inc;..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/User
    ../Src/: global.c main.c gpio.c adc.c can.c dma.c freertos.c i2c.c iwdg.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/CMSIS
    ./: startup_stm32f429xx.s
    ../Src/: system_stm32f4xx.c
  group DRIVER
    ../USER/DRIVER/: board.c pca9685.c pwm.c switch.c Batt.c led.c myiic.c manipulaterD2.c
    ../USER/STMFLASH/: stmflash.c
  group TASK
    ../USER/TASK/: ledTasks.c messageTasks.c pressureTasks.c sensorTasks.c controlTasks.c imuTasks.c
  group CONTROL
    ../USER/CONTROL/: control.c data_parse.c PID.c
    ../USER/DRIVER/: Kalman_filtering.c
  group SENSOR
    ../USER/DRIVER/: IMU.c mcp3221.c ms5837.c SHT35.c IAP.c
  group W5500
    ../USER/W5500/: socket.c udp.c w5500.c wizchip_conf.c
  group MATH
    ../USER/MATH/: mathTool.c
  group ReadMe
    ../USER/: ReadMe.txt
  group Version
    ../USER/Version/: Version.c
  group Message
    ../USER/MESSAGE/: MTLink.c Object.c MTLINK_V1.lib
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group CAN
    ../USER/CANNetwork/: CANOpen_CMD.c CANOpen_EPDO.c CANOpen_RPDO.c CANOpen_SDO.c CANOpen_SYNC.c CANOpen_TPDO.c CanOpenNetWork.c MyCAN.c
software components: CMSIS:CORE 4.3.0
